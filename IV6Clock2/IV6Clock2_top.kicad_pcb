# Repository SarahAlroe/IV-6-Clock

## KiCad design IV6Clock2/IV6Clock2_top.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J3: Conn_01x08; PinSocket_1x08_P2.54mm_Vertical
J2: Conn_01x32; PinSocket_1x32_P2.54mm_Vertical
J4, J5: Conn_01x02; PinSocket_1x02_P2.54mm_Vertical
VFD1, VFD2, VFD3, VFD4, VFD5, VFD6: IV-6

Connections:
+1V0: J4.2, VFD1.8 (Fil+), VFD2.8 (Fil+), VFD3.8 (Fil+), VFD4.8 (Fil+), VFD5.8 (Fil+), VFD6.8 (Fil+)
+12V: J5.2, VFD1.9 (Grid), VFD2.9 (Grid), VFD3.9 (Grid), VFD4.9 (Grid), VFD5.9 (Grid), VFD6.9 (Grid)
GND: J4.1, J5.1, VFD1.7 (Fil-), VFD2.7 (Fil-), VFD3.7 (Fil-), VFD4.7 (Fil-), VFD5.7 (Fil-), VFD6.7 (Fil-)
unnamed: J1.1, VFD1.1 (B)
unnamed: J1.2, VFD1.2 (A)
unnamed: J1.3, VFD1.3 (G)
unnamed: J1.4, VFD1.4 (F)
unnamed: J1.5, VFD1.5 (E)
unnamed: J1.6, VFD1.6 (D)
unnamed: J1.7, VFD1.10 (C)
unnamed: J1.8, VFD1.11 (DP)
unnamed: J3.1, VFD6.1 (B)
unnamed: J3.2, VFD6.2 (A)
unnamed: J3.3, VFD6.3 (G)
unnamed: J3.4, VFD6.4 (F)
unnamed: J3.5, VFD6.5 (E)
unnamed: J3.6, VFD6.6 (D)
unnamed: J3.7, VFD6.10 (C)
unnamed: J3.8, VFD6.11 (DP)
SEG21: J2.1, VFD2.1 (B)
SEG22: J2.2, VFD2.2 (A)
SEG23: J2.3, VFD2.3 (G)
SEG24: J2.4, VFD2.4 (F)
SEG25: J2.5, VFD2.5 (E)
SEG26: J2.6, VFD2.6 (D)
SEG27: J2.7, VFD2.10 (C)
SEG28: J2.8, VFD2.11 (DP)
SEG31: J2.9, VFD3.1 (B)
SEG32: J2.10, VFD3.2 (A)
SEG33: J2.11, VFD3.3 (G)
SEG34: J2.12, VFD3.4 (F)
SEG35: J2.13, VFD3.5 (E)
SEG36: J2.14, VFD3.6 (D)
SEG37: J2.15, VFD3.10 (C)
SEG38: J2.16, VFD3.11 (DP)
SEG41: J2.17, VFD4.1 (B)
SEG42: J2.18, VFD4.2 (A)
SEG43: J2.19, VFD4.3 (G)
SEG44: J2.20, VFD4.4 (F)
SEG45: J2.21, VFD4.5 (E)
SEG46: J2.22, VFD4.6 (D)
SEG47: J2.23, VFD4.10 (C)
SEG48: J2.24, VFD4.11 (DP)
SEG51: J2.25, VFD5.1 (B)
SEG52: J2.26, VFD5.2 (A)
SEG53: J2.27, VFD5.3 (G)
SEG54: J2.28, VFD5.4 (F)
SEG55: J2.29, VFD5.5 (E)
SEG56: J2.30, VFD5.6 (D)
SEG57: J2.31, VFD5.10 (C)
SEG58: J2.32, VFD5.11 (DP)

Board: 2 copper layers, 99.1 x 45.7 mm, 15 parts (0 on the bottom side), 51 nets.

## KiCad design IV6Clock2/IV6Clock2_base.kicad_pcb

Parts:
BT1: Battery_Cell; BatteryHolder_Keystone_3001_1x12mm
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1: 220µ; CP_Radial_D6.3mm_P2.50mm
C2, C3: 0.1µ; C_Disc_D5.1mm_W3.2mm_P5.00mm
C4, C5, C8: 4.7µ; C_Disc_D4.7mm_W2.5mm_P5.00mm
C6, C7: 22µ; C_Disc_D4.7mm_W2.5mm_P5.00mm
D1: 1N5819; D_DO-41_SOD81_P10.16mm_Horizontal
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: DC005; BarrelJack_Horizontal
J2: Debug; PinSocket_1x05_P2.54mm_Vertical
J3, J4, J5: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical
J6: Conn_01x01; PinSocket_1x01_P2.54mm_Vertical
L1: 2.2µ; L_Radial_D8.7mm_P5.00mm_Fastron_07HCP
L2: 10µ; L_Radial_D8.7mm_P5.00mm_Fastron_07HCP
R1, R2: 20K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 66.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6: R_PHOTO; R_LDR_5.1x4.3mm_P3.4mm_Vertical
R7: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8: 5.1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1: 3296 104; Potentiometer_Bourns_3296W_Vertical
SW1: <; SW_PUSH_6mm_H4.3mm
SW2: v; SW_PUSH_6mm_H4.3mm
SW3: >; SW_PUSH_6mm_H4.3mm
U1: ATmega328P-PU; DIP-28_W7.62mm
U2: DS3231M; SOIC-16W_7.5x10.3mm_P1.27mm
U3: TLV62568DBV; SOT-23-5
U4: AP3012KTR; SOT-23-5
U5: DS3232M; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+1V0: C6.1, C7.1, J4.2, L1.2, R4.1
+5V: C1.1, C2.1, C3.2, C4.1, C5.2, J1.1, J2.2, J4.3, L2.1, R1.1, R2.1, R6.1, U1.7 (VCC), U1.20 (AVCC), U2.2 (VCC), U3.1 (EN), U3.4 (VIN), U4.4 (*SHDN), U4.5 (VIN), U5.2 (VCC)
+12V: C8.1, D1.1 (K), J4.4, RV1.1
BUZ: R3.2, U1.19 (PB5)
DATA: J3.4, U1.26 (PC3)
GND: BT1.2 (-), BZ1.2 (+), C1.2, C2.2, C3.1, C4.2, C5.1, C6.2, C7.2, C8.2, J1.2, J2.1, J3.1, J4.1, R5.2, R7.2, R8.2, SW1.2, SW2.2, SW3.2, U1.8 (GND), U1.22 (GND), U2.5 (GND), U2.6 (GND), U2.7 (GND), U2.8 (GND), U2.9 (GND), U2.10 (GND), U2.11 (GND), U2.12 (GND), U2.13 (GND), U3.2 (GND), U4.2 (GND), U5.5 (GND)
INTSQW: J6.1, U2.3 (~INT~/SQW), U5.3 (~INT~/SQW)
LDR: R6.2, R7.1, U1.23 (PC0)
unnamed: BZ1.1 (-), R3.1
unnamed: D1.2 (A), L2.2, U4.1 (SW)
unnamed: J5.1, U1.15 (PB1)
unnamed: J5.2, U1.16 (PB2)
unnamed: J5.3, U1.17 (PB3)
unnamed: J5.4, U1.18 (PB4)
unnamed: L1.1, U3.3 (SW)
unnamed: R4.2, R5.1, U3.5 (FB)
unnamed: R8.1, RV1.2, U4.3 (FB)
unnamed: SW1.1, U1.4 (PD2)
unnamed: SW2.1, U1.5 (PD3)
unnamed: SW3.1, U1.6 (PD4)
RCLK: J3.3, U1.25 (PC2)
RESET: J2.5, U1.1 (~RESET~/PC6)
RXD: J2.4, U1.2 (PD0)
SCL: R2.2, U1.28 (PC5), U2.16 (SCL), U5.8 (SCL)
SDA: R1.2, U1.27 (PC4), U2.15 (SDA), U5.7 (SDA)
SRCLK: J3.2, U1.24 (PC1)
TXD: J2.3, U1.3 (PD1)
VBAT: BT1.1 (+), U2.14 (VBAT), U5.6 (VBAT)

Notes on the sheet:
Alternative IC with alternative footprint

Board: 2 copper layers, 99.1 x 45.7 mm, 40 parts (0 on the bottom side), 28 nets.

## KiCad design IV6Clock2/IV6Clock2_middle.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J6: Conn_01x08; PinSocket_1x08_P2.54mm_Vertical
J2: Conn_01x32; PinSocket_1x32_P2.54mm_Vertical
J7, J8: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical
J9, J10: Conn_01x02; PinSocket_1x02_P2.54mm_Vertical
RN1, RN2, RN3, RN4, RN5, RN6: 10K; R_Array_SIP9
U1, U2, U3, U7, U8, U9: 74HC595; SOIC-16_3.9x9.9mm_P1.27mm
U4, U5, U6, U10, U11, U12: ULN2803A; SOIC-18W_7.5x11.6mm_P1.27mm

Connections:
+1V0: J8.2, J9.2
+5V: J8.3, U1.10 (~SRCLR), U1.16 (VCC), U2.10 (~SRCLR), U2.16 (VCC), U3.10 (~SRCLR), U3.16 (VCC), U7.10 (~SRCLR), U7.16 (VCC), U8.10 (~SRCLR), U8.16 (VCC), U9.10 (~SRCLR), U9.16 (VCC)
+12V: J8.4, J10.2, RN1.1 (common), RN2.1 (common), RN3.1 (common), RN4.1 (common), RN5.1 (common), RN6.1 (common), U4.10 (COM), U5.10 (COM), U6.10 (COM), U10.10 (COM), U11.10 (COM), U12.10 (COM)
DATA: J7.4, U1.14 (SER)
GND: J7.1, J8.1, J9.1, J10.1, U1.8 (GND), U1.13 (~OE), U2.8 (GND), U2.13 (~OE), U3.8 (GND), U3.13 (~OE), U4.9 (GND), U5.9 (GND), U6.9 (GND), U7.8 (GND), U7.13 (~OE), U8.8 (GND), U8.13 (~OE), U9.8 (GND), U9.13 (~OE), U10.9 (GND), U11.9 (GND), U12.9 (GND)
unnamed: J1.1, RN1.2 (R1), U4.18 (O1)
unnamed: J1.2, RN1.3 (R2), U4.17 (O2)
unnamed: J1.3, RN1.4 (R3), U4.16 (O3)
unnamed: J1.4, RN1.5 (R4), U4.15 (O4)
unnamed: J1.5, RN1.6 (R5), U4.14 (O5)
unnamed: J1.6, RN1.7 (R6), U4.13 (O6)
unnamed: J1.7, RN1.8 (R7), U4.12 (O7)
unnamed: J1.8, RN1.9 (R8), U4.11 (O8)
unnamed: J6.1, RN6.2 (R1), U12.18 (O1)
unnamed: J6.2, RN6.3 (R2), U12.17 (O2)
unnamed: J6.3, RN6.4 (R3), U12.16 (O3)
unnamed: J6.4, RN6.5 (R4), U12.15 (O4)
unnamed: J6.5, RN6.6 (R5), U12.14 (O5)
unnamed: J6.6, RN6.7 (R6), U12.13 (O6)
unnamed: J6.7, RN6.8 (R7), U12.12 (O7)
unnamed: J6.8, RN6.9 (R8), U12.11 (O8)
unnamed: U1.1 (QB), U4.7 (I7)
unnamed: U1.2 (QC), U4.6 (I6)
unnamed: U1.3 (QD), U4.5 (I5)
unnamed: U1.4 (QE), U4.4 (I4)
unnamed: U1.5 (QF), U4.3 (I3)
unnamed: U1.6 (QG), U4.2 (I2)
unnamed: U1.7 (QH), U4.1 (I1)
unnamed: U1.9 (QH'), U2.14 (SER)
unnamed: U1.15 (QA), U4.8 (I8)
unnamed: U2.1 (QB), U5.7 (I7)
unnamed: U2.2 (QC), U5.6 (I6)
unnamed: U2.3 (QD), U5.5 (I5)
unnamed: U2.4 (QE), U5.4 (I4)
unnamed: U2.5 (QF), U5.3 (I3)
unnamed: U2.6 (QG), U5.2 (I2)
unnamed: U2.7 (QH), U5.1 (I1)
unnamed: U2.9 (QH'), U3.14 (SER)
unnamed: U2.15 (QA), U5.8 (I8)
unnamed: U3.1 (QB), U6.7 (I7)
unnamed: U3.2 (QC), U6.6 (I6)
unnamed: U3.3 (QD), U6.5 (I5)
unnamed: U3.4 (QE), U6.4 (I4)
unnamed: U3.5 (QF), U6.3 (I3)
unnamed: U3.6 (QG), U6.2 (I2)
unnamed: U3.7 (QH), U6.1 (I1)
unnamed: U3.9 (QH'), U7.14 (SER)
unnamed: U3.15 (QA), U6.8 (I8)
unnamed: U7.9 (QH'), U8.14 (SER)
unnamed: U8.9 (QH'), U9.14 (SER)
unnamed: U7.7 (QH), U10.1 (I1)
unnamed: U7.6 (QG), U10.2 (I2)
unnamed: U7.5 (QF), U10.3 (I3)
unnamed: U7.4 (QE), U10.4 (I4)
unnamed: U7.3 (QD), U10.5 (I5)
unnamed: U7.2 (QC), U10.6 (I6)
unnamed: U7.1 (QB), U10.7 (I7)
unnamed: U7.15 (QA), U10.8 (I8)
unnamed: U8.7 (QH), U11.1 (I1)
unnamed: U8.6 (QG), U11.2 (I2)
unnamed: U8.5 (QF), U11.3 (I3)
unnamed: U8.4 (QE), U11.4 (I4)
unnamed: U8.3 (QD), U11.5 (I5)
unnamed: U8.2 (QC), U11.6 (I6)
unnamed: U8.1 (QB), U11.7 (I7)
unnamed: U8.15 (QA), U11.8 (I8)
unnamed: U9.7 (QH), U12.1 (I1)
unnamed: U9.6 (QG), U12.2 (I2)
unnamed: U9.5 (QF), U12.3 (I3)
unnamed: U9.4 (QE), U12.4 (I4)
unnamed: U9.3 (QD), U12.5 (I5)
unnamed: U9.2 (QC), U12.6 (I6)
unnamed: U9.1 (QB), U12.7 (I7)
unnamed: U9.15 (QA), U12.8 (I8)
RCLK: J7.3, U1.12 (RCLK), U2.12 (RCLK), U3.12 (RCLK), U7.12 (RCLK), U8.12 (RCLK), U9.12 (RCLK)
SEG21: J2.1, RN2.2 (R1), U5.18 (O1)
SEG22: J2.2, RN2.3 (R2), U5.17 (O2)
SEG23: J2.3, RN2.4 (R3), U5.16 (O3)
SEG24: J2.4, RN2.5 (R4), U5.15 (O4)
SEG25: J2.5, RN2.6 (R5), U5.14 (O5)
SEG26: J2.6, RN2.7 (R6), U5.13 (O6)
SEG27: J2.7, RN2.8 (R7), U5.12 (O7)
SEG28: J2.8, RN2.9 (R8), U5.11 (O8)
SEG31: J2.9, RN3.2 (R1), U6.18 (O1)
SEG32: J2.10, RN3.3 (R2), U6.17 (O2)
SEG33: J2.11, RN3.4 (R3), U6.16 (O3)
SEG34: J2.12, RN3.5 (R4), U6.15 (O4)
SEG35: J2.13, RN3.6 (R5), U6.14 (O5)
SEG36: J2.14, RN3.7 (R6), U6.13 (O6)
SEG37: J2.15, RN3.8 (R7), U6.12 (O7)
SEG38: J2.16, RN3.9 (R8), U6.11 (O8)
SEG41: J2.17, RN4.2 (R1), U10.18 (O1)
SEG42: J2.18, RN4.3 (R2), U10.17 (O2)
SEG43: J2.19, RN4.4 (R3), U10.16 (O3)
SEG44: J2.20, RN4.5 (R4), U10.15 (O4)
SEG45: J2.21, RN4.6 (R5), U10.14 (O5)
SEG46: J2.22, RN4.7 (R6), U10.13 (O6)
SEG47: J2.23, RN4.8 (R7), U10.12 (O7)
SEG48: J2.24, RN4.9 (R8), U10.11 (O8)
SEG51: J2.25, RN5.2 (R1), U11.18 (O1)
SEG52: J2.26, RN5.3 (R2), U11.17 (O2)
SEG53: J2.27, RN5.4 (R3), U11.16 (O3)
SEG54: J2.28, RN5.5 (R4), U11.15 (O4)
SEG55: J2.29, RN5.6 (R5), U11.14 (O5)
SEG56: J2.30, RN5.7 (R6), U11.13 (O6)
SEG57: J2.31, RN5.8 (R7), U11.12 (O7)
SEG58: J2.32, RN5.9 (R8), U11.11 (O8)
SRCLK: J7.2, U1.11 (SRCLK), U2.11 (SRCLK), U3.11 (SRCLK), U7.11 (SRCLK), U8.11 (SRCLK), U9.11 (SRCLK)

Board: 2 copper layers, 99.1 x 45.7 mm, 29 parts (0 on the bottom side), 108 nets.

## Code that names these connections

File IV-6-Clock.ino:

#include <DS3232RTC.h>
#include "Structure.h"
#include "Button.h"
#include "Alarm.h"
#include "Alarms.h"
#include "Display.h"
#include "ScreenManager.h"
#include "Screen.h"
#include "Buzzer.h"

// Pin configuration
const int LATCH_PIN = A2;  // ST_CP / rclk on shift register
const int CLOCK_PIN = A1;  // SH_CP / srclk on shift register
const int DATA_PIN = A3;   // DS / data on shift register
const int LDR_PIN = A0;    // LDR pin
const int BUZZER_PIN = 13; // Buzzer pin
const int L_BUTTON_PIN = 2; // Left button pin
const int M_BUTTON_PIN = 3; // Middle button pin
const int R_BUTTON_PIN = 4; // Right button pin

// Display
Display display(DATA_PIN, CLOCK_PIN, LATCH_PIN, LDR_PIN);

// Buzzer
Buzzer buzzer(BUZZER_PIN);

// Buttons
Button lButton(L_BUTTON_PIN);
Button mButton(M_BUTTON_PIN);
Button rButton(R_BUTTON_PIN);

// Screens
ScreenManager screenManager;

// Alarms
Alarms * alarms;

void setup() {
  // Init clock
  setSyncProvider(RTC.get);

  // Init serial
  Serial.begin(9600);

  // Init alarms
  alarms = alarms->getInstance();
}

void loop() {
  // Check alarms
  if (alarms -> isActive()) {
    buzzer.play(alarms->getActive()->getMelody());
    if (mButton.pressed()) {
      alarms -> stop();
      buzzer.stop();
    }
    else if (lButton.pressed() || rButton.pressed()) {
      alarms -> snooze();
    }
  }

  // Get screen to process input and be displayed
  Screen *currentScreen = screenManager.getCurrentScreen();

  // Handle input
  if (lButton.pressed()) {
    currentScreen->leftButtonPressed();
  }
  if (rButton.pressed()) {
    currentScreen->rightButtonPressed();
  }
  if (mButton.pressed()) {
    currentScreen->middleButtonPressed();
  }

  // Update display
  display.display(currentScreen->getDisplay());

  // Check if there's anything on the serial port
  checkSerialUpdate();
}

void checkSerialUpdate() {
  // Check if new time has been pushed over serial (in format yy,m,d,h,m,s)
  if (Serial.available() != 0) {
    time_t t;
    tmElements_t tm;

    // Parse new datetime. Convert year from double digit to since 1970
    int y = Serial.parseInt();
    tm.Year = y2kYearToTm(y);
    tm.Month = Serial.parseInt();
    tm.Day = Serial.parseInt();
    tm.Hour = Serial.parseInt();
    tm.Minute = Serial.parseInt();
    tm.Second = Serial.parseInt();

    // Convert to time_t object
    t = makeTime(tm);

    // Set RTC and locally kept time
    RTC.set(t);
    setTime(t);

    //Clear any further serial data
    while (Serial.available() > 0) Serial.read();
  }
}

## Commit log

2018-05-13 Init
2018-05-13 Added eagle design files
2020-08-10 Added new KiCad v2.0 boards. Removed old eagle and inventor files. Added gitignore.
2020-09-13 Fixed wrong pin i/o on base board
2020-09-13 Updated most display segment values
2020-09-25 Fixed alarm display, Fixed broken letters.
2021-01-29 Complete refactor
2021-01-29 Cleanup
2021-02-01 Added nonblocking display-pushing, summertime config, temperature screen with configurable units and autoreturn from menus.
2021-02-02 Added snooze functionality to alarms
2021-02-04 Added ability to play different alarm melodies.
2021-02-05 Added expanded melody. Reenabled screen animation.
