# Repository SarahAlroe/IV-6-Clock

## EAGLE design eagle-VFD Clock/Side 2.brd

Parts:
H1, H2: IV-6
J1, J2, J3, J4, J5, J6: CONN_08"; 1X08
J8, J9: CONN_02; 1X02
M1, M2: IV-6
RN1, RN2, RN3, RN4, RN5, RN6: RN08; RN-9
S1, S2: IV-6

Connections:
CAT: H1.CAT, H2.CAT, J9.1, M1.CAT, M2.CAT, S1.CAT, S2.CAT
GND: H1.GND, H2.GND, J8.2, J9.2, M1.GND, M2.GND, S1.GND, S2.GND
GRD: H1.GRD, H2.GRD, J8.1, M1.GRD, M2.GRD, RN1.1, RN2.1, RN3.1, RN4.1, RN5.1, RN6.1, S1.GRD, S2.GRD
H11: H1.SG6, J1.1, RN1.9
H12: H1.SG5, J1.2, RN1.8
H13: H1.SG4, J1.3, RN1.7
H14: H1.SG3, J1.4, RN1.6
H15: H1.SG2, J1.5, RN1.5
H16: H1.SG1, J1.6, RN1.4
H17: H1.SG8, J1.7, RN1.3
H18: H1.SG7, J1.8, RN1.2
H21: H2.SG6, J2.1, RN2.2
H22: H2.SG5, J2.2, RN2.3
H23: H2.SG4, J2.3, RN2.4
H24: H2.SG3, J2.4, RN2.5
H25: H2.SG2, J2.5, RN2.6
H26: H2.SG1, J2.6, RN2.7
H27: H2.SG8, J2.7, RN2.8
H28: H2.SG7, J2.8, RN2.9
M11: J3.1, M1.SG6, RN3.2
M12: J3.2, M1.SG5, RN3.3
M13: J3.3, M1.SG4, RN3.4
M14: J3.4, M1.SG3, RN3.5
M15: J3.5, M1.SG2, RN3.6
M16: J3.6, M1.SG1, RN3.7
M17: J3.7, M1.SG8, RN3.8
M18: J3.8, M1.SG7, RN3.9
M21: J4.1, M2.SG6, RN4.9
M22: J4.2, M2.SG5, RN4.8
M23: J4.3, M2.SG4, RN4.7
M24: J4.4, M2.SG3, RN4.6
M25: J4.5, M2.SG2, RN4.5
M26: J4.6, M2.SG1, RN4.4
M27: J4.7, M2.SG8, RN4.3
M28: J4.8, M2.SG7, RN4.2
S11: J5.1, RN5.9, S1.SG6
S12: J5.2, RN5.8, S1.SG5
S13: J5.3, RN5.7, S1.SG4
S14: J5.4, RN5.6, S1.SG3
S15: J5.5, RN5.5, S1.SG2
S16: J5.6, RN5.4, S1.SG1
S17: J5.7, RN5.3, S1.SG8
S18: J5.8, RN5.2, S1.SG7
S21: J6.1, RN6.9, S2.SG6
S22: J6.2, RN6.8, S2.SG5
S23: J6.3, RN6.7, S2.SG4
S24: J6.4, RN6.6, S2.SG3
S25: J6.5, RN6.5, S2.SG2
S26: J6.6, RN6.4, S2.SG1
S27: J6.7, RN6.3, S2.SG8
S28: J6.8, RN6.2, S2.SG7

Board: 2 copper layers, 99.1 x 45.5 mm, 21 parts (1 on the bottom side), 51 nets.

Other parts of the board:
U$1: OSHW-LOGO-L

## EAGLE design eagle-VFD Clock/old edits/Side 1 v1.1.brd

Parts:
C1, C4: 0.1µF; CAP-0.1I
C_C: 1µF; CAP_POL_2MM
C_IN1: 120µF; CAP_POL_3MM
C_OUT1, C_OUT2: 220µF; CPOL-RADIAL-5MM-10MM
D1: 1N5819-B; DO41-7.6
G1: BAT; CELL_RETAINER_11.6MM
IC1: LM317TS; 317TS
J1: POWER_JACK; POWER_JACK_PTH
J2: CONN_05; 1X05
J7, J10: CONN_04; 1X04
L1: 33µH; MICC12
LM2587: LM2587S; TO263-5
PH1: 5528
R1: 3K; AXIAL-0.3
R2: 100; AXIAL-0.3
R4: 10K; AXIAL-0.3
R5, R6: 20K; AXIAL-0.3
S1: v; TACTILE_SWITCH_PTH_6.0MM
S2: >; TACTILE_SWITCH_PTH_6.0MM
S3: <; TACTILE_SWITCH_PTH_6.0MM
SG1: F/TMB
U1: ATMEGA328P-PU; DIP254P762X457-28
U$1: DS3232; SO20-2
U$2: DS3232M; SO8
U$3: MCP41HVX1; MCP41HVX1_BREAKOUT

Connections:
5V: C1.1, C4.2, C_IN1.POS (+), IC1.3 (IN), J1.PWR, J2.2, J7.4, L1.2, LM2587.5 (VIN), PH1.1, R5.P$2 (2), R6.P$1 (1), U1.7 (VCC), U1.20 (AVCC), U$1.VCC, U$2.2 (VCC), U$3.5V
BAT: G1.P+@1 (+), G1.P+@2 (+), U$1.V_{BAT} (VBAT), U$2.6 (VBAT)
BUZ: R2.P$2 (2), U1.23 (PC0)
BUZR: R2.P$1 (1), SG1.+
CAT: IC1.2 (OUT), J7.3
DATA: J10.1, U1.26 (PC3)
GND: C1.2, C4.1, C_C.NEG (-), C_IN1.NEG (-), C_OUT1.-, C_OUT2.-, G1.N- (-), IC1.1 (ADJ), J1.GND, J2.1, J7.1, J10.4, LM2587.3 (GND), R4.P$1 (1), S1.1, S2.1, S3.1, SG1.-, U1.8 (GND_2), U1.22 (GND), U$1.GND, U$1.N.C.-0 (GND), U$1.N.C.-1 (GND), U$1.N.C.-2 (GND), U$1.N.C.-3 (GND), U$1.N.C.-4 (GND), U$1.N.C.-5 (GND), U$1.N.C.-6 (GND), U$1.N.C.-7 (GND), U$1.N.C.-8 (GND), U$1.N.C.-9 (GND), U$1.N.C.-10 (GND), U$2.5 (GND), U$3.GND
LBUT: S3.3 (2), U1.4 (PD2)
LDR: PH1.2, R4.P$2 (2), U1.15 (PB1)
MBUT: S1.3 (2), U1.5 (PD3)
MISO: U1.18 (PB4), U$3.MISO
MOSI: U1.17 (PB3), U$3.MOSI
unnamed: D1.A, L1.1, LM2587.4 (SW)
unnamed: LM2587.1 (CMP), R1.P$2 (2)
unnamed: C_C.POS (+), R1.P$1 (1)
unnamed: LM2587.2 (FB), U$3.WIPER
RBUT: S2.3 (2), U1.6 (PD4)
RCLK: J10.2, U1.25 (PC2)
RESET: J2.5, U1.1 (PC6)
RXD: J2.4, U1.2 (PD0)
SCK: U1.16 (PB2), U$3.SCK
SCL: R5.P$1 (1), U1.28 (PC5), U$1.SCL@0 (SCL), U$2.8 (SCL)
SDA: R6.P$2 (2), U1.27 (PC4), U$1.SDA, U$2.7 (SDA)
SHDN: U1.19 (PB5), U$3.SHDN
SRCLK: J10.3, U1.24 (PC1)
TXD: J2.3, U1.3 (PD1)
VCC: C_OUT1.+, C_OUT2.+, D1.C, J7.2, U$3.HIV

Board: 2 copper layers, 99.1 x 45.5 mm, 30 parts (0 on the bottom side), 27 nets.

Other parts of the board:
U$4: OSHW-LOGO-L_COPPER_BOTTOM

## EAGLE design eagle-VFD Clock/Side 1½.brd

Parts:
IC1, IC2, IC3, IC4, IC5, IC6: ULN2802A; DIL18
J1, J2, J3, J4, J5, J6: CONN_08"; 1X08
J7, J10: CONN_04; 1X04
J8, J9: CONN_02; 1X02
SR1, SR2, SR3, SR4, SR5, SR6: 74HC595; DIL16

Connections:
5V: J7.4, SR1.10 (SRCLR), SR1.16 (VCC), SR2.10 (SRCLR), SR2.16 (VCC), SR3.10 (SRCLR), SR3.16 (VCC), SR4.10 (SRCLR), SR4.16 (VCC), SR5.10 (SRCLR), SR5.16 (VCC), SR6.10 (SRCLR), SR6.16 (VCC)
CAT: J7.3, J9.1
DATA: J10.3, SR1.14 (SER)
GND: IC1.9 (GND), IC2.9 (GND), IC3.9 (GND), IC4.9 (GND), IC5.9 (GND), IC6.9 (GND), J7.1, J8.2, J9.2, J10.4, SR1.8 (GND), SR1.13 (OE), SR2.8 (GND), SR2.13 (OE), SR3.8 (GND), SR3.13 (OE), SR4.8 (GND), SR4.13 (OE), SR5.8 (GND), SR5.13 (OE), SR6.8 (GND), SR6.13 (OE)
GRD: IC1.10 (CD+), IC2.10 (CD+), IC3.10 (CD+), IC4.10 (CD+), IC5.10 (CD+), IC6.10 (CD+), J7.2, J8.1
H11: IC1.18 (O1), J1.1
H12: IC1.17 (O2), J1.2
H13: IC1.16 (O3), J1.3
H14: IC1.15 (O4), J1.4
H15: IC1.14 (O5), J1.5
H16: IC1.13 (O6), J1.6
H17: IC1.12 (O7), J1.7
H18: IC1.11 (O8), J1.8
H21: IC2.18 (O1), J2.1
H22: IC2.17 (O2), J2.2
H23: IC2.16 (O3), J2.3
H24: IC2.15 (O4), J2.4
H25: IC2.14 (O5), J2.5
H26: IC2.13 (O6), J2.6
H27: IC2.12 (O7), J2.7
H28: IC2.11 (O8), J2.8
M11: IC3.18 (O1), J3.1
M12: IC3.17 (O2), J3.2
M13: IC3.16 (O3), J3.3
M14: IC3.15 (O4), J3.4
M15: IC3.14 (O5), J3.5
M16: IC3.13 (O6), J3.6
M17: IC3.12 (O7), J3.7
M18: IC3.11 (O8), J3.8
unnamed: SR1.9 (QH'), SR2.14 (SER)
unnamed: SR2.9 (QH'), SR3.14 (SER)
unnamed: SR3.9 (QH'), SR4.14 (SER)
unnamed: SR4.9 (QH'), SR5.14 (SER)
unnamed: SR5.9 (QH'), SR6.14 (SER)
unnamed: IC3.8 (I8), SR3.15 (QA)
unnamed: IC3.7 (I7), SR3.1 (QB)
unnamed: IC3.6 (I6), SR3.2 (QC)
unnamed: IC3.5 (I5), SR3.3 (QD)
unnamed: IC3.4 (I4), SR3.4 (QE)
unnamed: IC3.3 (I3), SR3.5 (QF)
unnamed: IC3.2 (I2), SR3.6 (QG)
unnamed: IC3.1 (I1), SR3.7 (QH)
unnamed: IC2.8 (I8), SR2.15 (QA)
unnamed: IC2.7 (I7), SR2.1 (QB)
unnamed: IC2.6 (I6), SR2.2 (QC)
unnamed: IC2.5 (I5), SR2.3 (QD)
unnamed: IC2.4 (I4), SR2.4 (QE)
unnamed: IC2.3 (I3), SR2.5 (QF)
unnamed: IC2.2 (I2), SR2.6 (QG)
unnamed: IC2.1 (I1), SR2.7 (QH)
unnamed: IC1.8 (I8), SR1.15 (QA)
unnamed: IC1.7 (I7), SR1.1 (QB)
unnamed: IC1.6 (I6), SR1.2 (QC)
unnamed: IC4.5 (I5), SR4.3 (QD)
unnamed: IC1.5 (I5), SR1.3 (QD)
unnamed: IC1.4 (I4), SR1.4 (QE)
unnamed: IC1.3 (I3), SR1.5 (QF)
unnamed: IC1.2 (I2), SR1.6 (QG)
unnamed: IC1.1 (I1), SR1.7 (QH)
unnamed: IC4.8 (I8), SR4.15 (QA)
unnamed: IC4.7 (I7), SR4.1 (QB)
unnamed: IC4.6 (I6), SR4.2 (QC)
unnamed: IC4.4 (I4), SR4.4 (QE)
unnamed: IC4.3 (I3), SR4.5 (QF)
unnamed: IC4.2 (I2), SR4.6 (QG)
unnamed: IC4.1 (I1), SR4.7 (QH)
unnamed: IC5.8 (I8), SR5.15 (QA)
unnamed: IC5.7 (I7), SR5.1 (QB)
unnamed: IC5.6 (I6), SR5.2 (QC)
unnamed: IC5.5 (I5), SR5.3 (QD)
unnamed: IC5.4 (I4), SR5.4 (QE)
unnamed: IC5.3 (I3), SR5.5 (QF)
unnamed: IC5.2 (I2), SR5.6 (QG)
unnamed: IC5.1 (I1), SR5.7 (QH)
unnamed: IC6.1 (I1), SR6.15 (QA)
unnamed: IC6.2 (I2), SR6.1 (QB)
unnamed: IC6.3 (I3), SR6.2 (QC)
unnamed: IC6.4 (I4), SR6.3 (QD)
unnamed: IC6.5 (I5), SR6.4 (QE)
unnamed: IC6.6 (I6), SR6.5 (QF)
unnamed: IC6.7 (I7), SR6.6 (QG)
unnamed: IC6.8 (I8), SR6.7 (QH)
unnamed: IC6.11 (O8), J6.1
unnamed: IC6.12 (O7), J6.2
unnamed: IC6.13 (O6), J6.3
unnamed: IC6.14 (O5), J6.4
unnamed: IC6.15 (O4), J6.5
unnamed: IC6.16 (O3), J6.6
unnamed: IC6.17 (O2), J6.7
unnamed: IC6.18 (O1), J6.8
unnamed: IC5.18 (O1), J5.1
unnamed: IC5.17 (O2), J5.2
unnamed: IC5.16 (O3), J5.3
unnamed: IC5.15 (O4), J5.4
unnamed: IC5.14 (O5), J5.5
unnamed: IC5.13 (O6), J5.6
unnamed: IC5.12 (O7), J5.7
unnamed: IC5.11 (O8), J5.8
unnamed: IC4.18 (O1), J4.1
unnamed: IC4.17 (O2), J4.2
unnamed: IC4.16 (O3), J4.3
unnamed: IC4.15 (O4), J4.4
unnamed: IC4.14 (O5), J4.5
unnamed: IC4.13 (O6), J4.6
unnamed: IC4.12 (O7), J4.7
unnamed: IC4.11 (O8), J4.8
RCLK: J10.2, SR1.12 (RCLK), SR2.12 (RCLK), SR3.12 (RCLK), SR4.12 (RCLK), SR5.12 (RCLK), SR6.12 (RCLK)
SRCLK: J10.1, SR1.11 (SRCLK), SR2.11 (SRCLK), SR3.11 (SRCLK), SR4.11 (SRCLK), SR5.11 (SRCLK), SR6.11 (SRCLK)

Notes on the sheet:
NOTE: CHIP REVERSED, LOGIC SAME

Board: 2 copper layers, 99.1 x 45.5 mm, 22 parts (0 on the bottom side), 108 nets.

## EAGLE design eagle-VFD Clock/old edits/Side 1 esp32 old.brd

Parts:
C_C: 1µF; CAP_POL_2MM
C_IN1: 120µF; CAP_POL_3MM
C_OUT1, C_OUT2: 220µF; CPOL-RADIAL-5MM-10MM
D1: 1N5819-B; DO41-7.6
ESP32: ESP32_DEVKIT
IC1: LM317TS; 317TS
J1: POWER_JACK; POWER_JACK_PTH
J7, J10: CONN_04; 1X04
L1: 33µH; MICC12
LM2587: LM2587S; TO263-5
PH1: 5528
R1: 3K; AXIAL-0.3
R2, R4: 10K; AXIAL-0.3
S1: v; TACTILE_SWITCH_PTH_6.0MM
S2: >; TACTILE_SWITCH_PTH_6.0MM
S3: <; TACTILE_SWITCH_PTH_6.0MM
SG1: F/TMB
T1: BC547; TO92
VR1: 3296W-1-103LF; W

Connections:
5V: C_IN1.POS (+), ESP32.P$20 (5V), IC1.3 (IN), J1.PWR, J7.4, L1.2, LM2587.5 (VIN), PH1.1, SG1.+
CAT: IC1.2 (OUT), J7.3
DATA: ESP32.P$27 (IO14), J10.1
GND: C_C.NEG (-), C_IN1.NEG (-), C_OUT1.-, C_OUT2.-, ESP32.P$19 (GND), ESP32.P$25 (GND), IC1.1 (ADJ), J1.GND, J7.1, J10.4, LM2587.3 (GND), R4.P$1 (1), S1.1, S2.1, S3.1, T1.1 (E), VR1.1
unnamed: D1.A, L1.1, LM2587.4 (SW)
unnamed: LM2587.1 (CMP), R1.P$2 (2)
unnamed: LM2587.2 (FB), VR1.2
unnamed: C_C.POS (+), R1.P$1 (1)
unnamed: ESP32.P$34 (IO34), PH1.2, R4.P$2 (2)
unnamed: ESP32.P$17 (IO22), S1.3 (2)
unnamed: ESP32.P$18 (IO23), S3.3 (2)
unnamed: ESP32.P$14 (IO21), S2.3 (2)
unnamed: SG1.-, T1.3 (C)
unnamed: R2.P$1 (1), T1.2 (B)
unnamed: ESP32.P$32 (IO32), R2.P$2 (2)
RCLK: ESP32.P$28 (IO27), J10.2
SRCLK: ESP32.P$29 (IO26), J10.3
VCC: C_OUT1.+, C_OUT2.+, D1.C, J7.2, VR1.3

Board: 2 copper layers, 99.1 x 45.5 mm, 22 parts (0 on the bottom side), 18 nets.

## EAGLE design eagle-VFD Clock/DigiPot breakout.brd

Parts:
C1, C2: 0.1µF; CAP-0.1I
IC1: MCP41HVX1ST; TSSOP14
J1, J2: CONN_04; 1X04
J3: CONN_01; 1X01
R1: 20k; AXIAL-0.3

Connections:
5V: C1.2, IC1.1 (VL), J1.1
CS: IC1.3 (!CS), J3.1
GND: C1.1, C2.1, IC1.6 (!WLAT), IC1.9 (DGND), IC1.10 (V-), IC1.13 (P0A), J1.2, R1.P$1 (1)
MISO: IC1.5 (SDO), J2.3
MOSI: IC1.4 (SDI), J2.2
SCK: IC1.2 (SCK), J2.1
SHDN: IC1.7 (!SHDN), J2.4, R1.P$2 (2)
VHI: C2.2, IC1.11 (P0B), IC1.14 (V+), J1.4
WIPER: IC1.12 (P0W), J1.3

Board: 2 copper layers, 12.7 x 17.8 mm, 8 parts (1 on the bottom side), 9 nets.

Other parts of the board:
U$1: OSHW-LOGO-S_COPPER

## Code that names these connections

File IV-6-Clock.ino:

#include <DS3232RTC.h>
#include "Structure.h"
#include "Button.h"
#include "Alarm.h"
#include "Alarms.h"
#include "Display.h"
#include "ScreenManager.h"
#include "Screen.h"
#include "Buzzer.h"

// Pin configuration
const int LATCH_PIN = A2;  // ST_CP / rclk on shift register
const int CLOCK_PIN = A1;  // SH_CP / srclk on shift register
const int DATA_PIN = A3;   // DS / data on shift register
const int LDR_PIN = A0;    // LDR pin
const int BUZZER_PIN = 13; // Buzzer pin
const int L_BUTTON_PIN = 2; // Left button pin
const int M_BUTTON_PIN = 3; // Middle button pin
const int R_BUTTON_PIN = 4; // Right button pin

// Display
Display display(DATA_PIN, CLOCK_PIN, LATCH_PIN, LDR_PIN);

// Buzzer
Buzzer buzzer(BUZZER_PIN);

// Buttons
Button lButton(L_BUTTON_PIN);
Button mButton(M_BUTTON_PIN);
Button rButton(R_BUTTON_PIN);

// Screens
ScreenManager screenManager;

// Alarms
Alarms * alarms;

void setup() {
  // Init clock
  setSyncProvider(RTC.get);

  // Init serial
  Serial.begin(9600);

  // Init alarms
  alarms = alarms->getInstance();
}

void loop() {
  // Check alarms
  if (alarms -> isActive()) {
    buzzer.play(alarms->getActive()->getMelody());
    if (mButton.pressed()) {
      alarms -> stop();
      buzzer.stop();
    }
    else if (lButton.pressed() || rButton.pressed()) {
      alarms -> snooze();
    }
  }

  // Get screen to process input and be displayed
  Screen *currentScreen = screenManager.getCurrentScreen();

  // Handle input
  if (lButton.pressed()) {
    currentScreen->leftButtonPressed();
  }
  if (rButton.pressed()) {
    currentScreen->rightButtonPressed();
  }
  if (mButton.pressed()) {
    currentScreen->middleButtonPressed();
  }

  // Update display
  display.display(currentScreen->getDisplay());

  // Check if there's anything on the serial port
  checkSerialUpdate();
}

void checkSerialUpdate() {
  // Check if new time has been pushed over serial (in format yy,m,d,h,m,s)
  if (Serial.available() != 0) {
    time_t t;
    tmElements_t tm;

    // Parse new datetime. Convert year from double digit to since 1970
    int y = Serial.parseInt();
    tm.Year = y2kYearToTm(y);
    tm.Month = Serial.parseInt();
    tm.Day = Serial.parseInt();
    tm.Hour = Serial.parseInt();
    tm.Minute = Serial.parseInt();
    tm.Second = Serial.parseInt();

    // Convert to time_t object
    t = makeTime(tm);

    // Set RTC and locally kept time
    RTC.set(t);
    setTime(t);

    //Clear any further serial data
    while (Serial.available() > 0) Serial.read();
  }
}

## Commit log

2018-05-13 Init
2018-05-13 Added eagle design files
2020-08-10 Added new KiCad v2.0 boards. Removed old eagle and inventor files. Added gitignore.
2020-09-13 Fixed wrong pin i/o on base board
2020-09-13 Updated most display segment values
2020-09-25 Fixed alarm display, Fixed broken letters.
2021-01-29 Complete refactor
2021-01-29 Cleanup
2021-02-01 Added nonblocking display-pushing, summertime config, temperature screen with configurable units and autoreturn from menus.
2021-02-02 Added snooze functionality to alarms
2021-02-04 Added ability to play different alarm melodies.
2021-02-05 Added expanded melody. Reenabled screen animation.

Notices in the files:
parts and their libraries:
SparkFun-Resistors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
Volks73-Bourns: Creative Commons Attribution-ShareAlike 3.0 Unported (CC BY-SA 3.0), http://creativecommons.org/licenses/by-sa/3.0/.
